* /Users/eru/Documents/ultrasonics/chinese_driver/spice/chinese_driver.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Monday, November 20, 2017 'PMt' 03:02:16 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ .33uF
R2  Net-_D3-Pad2_ Net-_C2-Pad2_ 47k
R1  Net-_C2-Pad1_ Net-_C2-Pad2_ 510
R3  Net-_C3-Pad1_ Net-_C3-Pad2_ 47k
R4  Net-_R4-Pad1_ Net-_J2-Pad1_ 0.51
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ .33uF
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ .33uF
C5  Net-_C4-Pad1_ Net-_C5-Pad2_ .33uF
Q1  Net-_C2-Pad2_ Net-_D3-Pad2_ Net-_C4-Pad1_ d13009k
Q2  Net-_C3-Pad2_ Net-_C4-Pad2_ Net-_Q2-Pad3_ d13009k
D2  Net-_C1-Pad1_ Net-_C4-Pad1_ 1N4007
D1  Net-_C1-Pad2_ Net-_C4-Pad1_ 1N4007
D4  Net-_C4-Pad2_ Net-_C1-Pad2_ 1N4007
D3  Net-_C4-Pad2_ Net-_D3-Pad2_ FR107
D5  Net-_D3-Pad2_ Net-_C4-Pad1_ FR107
C3  Net-_C3-Pad1_ Net-_C3-Pad2_ .66uF
J2  Net-_J2-Pad1_ Net-_J2-Pad2_ output
J1  Net-_J1-Pad1_ Net-_J1-Pad2_ input
T1  Net-_J1-Pad2_ Net-_J1-Pad1_ Net-_C1-Pad2_ Net-_F1-Pad2_ Transformer_1P_1S
F1  Net-_C1-Pad1_ Net-_F1-Pad2_ Fuse
D6  Net-_C4-Pad2_ Net-_C1-Pad1_ 1N4007
L1  Net-_J2-Pad2_ Net-_L1-Pad2_ L
T3  Net-_C5-Pad2_ Net-_Q2-Pad3_ Net-_R4-Pad1_ Net-_L1-Pad2_ Transformer_1P_1S
T2  Net-_J2-Pad1_ Net-_R4-Pad1_ Net-_C4-Pad1_ Net-_C2-Pad1_ Net-_C3-Pad1_ Net-_Q2-Pad3_ Transformer_1P_2S

.end
